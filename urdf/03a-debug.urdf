Commit message: 1

File: urdf/03a-debug.urdf (robot description, URDF)
Before this commit: robot myrobot, 1 links, 0 joints
Links:
- added link axis
Joints:
- added joint leg1connect: type fixed, parent axis, child torso, origin xyz=0 .30 0
